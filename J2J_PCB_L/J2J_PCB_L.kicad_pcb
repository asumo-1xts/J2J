# Repository asumo-1xts/J2J

File README.md:

# J2J
Just the 2 of JIS - My ideal keyboard

## KiCad design J2J_PCB_L/J2J_PCB_L.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric
C2, C8: 105; C_0402_1005Metric
C3, C4, C7: 104; C_0402_1005Metric
C5, C6: 22pF; C_0402_1005Metric
D1: LED; LED_0603_1608Metric
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D17, D18, D19, D20, D21, D22, D24, D25, D26, D27, D28, D29, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41: 1N4148W; D_SOD-323
D16, D23, D30: LED; LED_0402_1005Metric
D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78: SK6812MINI-E; LED_SK6812MINI-E_3.2x2.8mm_P1.5mm_ReverseMount
F1: Fuse; Fuse_0805_2012Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: AudioJack3_SwitchTR; Jack_3.5mm_PJ320D_Horizontal
R1, R2: 5k1; R_0603_1608Metric
R3: 470; R_0603_1608Metric
R4, R5: 22; R_0402_1005Metric
R6: 10k; R_0603_1608Metric
R7, R8, R9: 470; R_0402_1005Metric
SW1: Fn; SW_Hotswap_Kailh_Choc_V2_1.00u
SW2: F1; SW_Hotswap_Kailh_Choc_V2_1.00u
SW3: F2; SW_Hotswap_Kailh_Choc_V2_1.00u
SW4: F3; SW_Hotswap_Kailh_Choc_V2_1.00u
SW5: F4; SW_Hotswap_Kailh_Choc_V2_1.00u
SW6: F5; SW_Hotswap_Kailh_Choc_V2_1.00u
SW7: F6; SW_Hotswap_Kailh_Choc_V2_1.00u
SW8: Esc; SW_Hotswap_Kailh_Choc_V2_1.00u
SW9: 1; SW_Hotswap_Kailh_Choc_V2_1.00u
SW10: 2; SW_Hotswap_Kailh_Choc_V2_1.00u
SW11: 3; SW_Hotswap_Kailh_Choc_V2_1.00u
SW12: 4; SW_Hotswap_Kailh_Choc_V2_1.00u
SW13: 5; SW_Hotswap_Kailh_Choc_V2_1.00u
SW14: 6; SW_Hotswap_Kailh_Choc_V2_1.00u
SW15: Tab; SW_Hotswap_Kailh_Choc_V2_1.50u
SW16: Q; SW_Hotswap_Kailh_Choc_V2_1.00u
SW17: W; SW_Hotswap_Kailh_Choc_V2_1.00u
SW18: E; SW_Hotswap_Kailh_Choc_V2_1.00u
SW19: R; SW_Hotswap_Kailh_Choc_V2_1.00u
SW20: T; SW_Hotswap_Kailh_Choc_V2_1.00u
SW21: Reset; SW_SPST_PTS647_Sx50
SW22: Ctrl; SW_Hotswap_Kailh_Choc_V2_1.75u
SW23: A; SW_Hotswap_Kailh_Choc_V2_1.00u
SW24: S; SW_Hotswap_Kailh_Choc_V2_1.00u
SW25: D; SW_Hotswap_Kailh_Choc_V2_1.00u
SW26: F; SW_Hotswap_Kailh_Choc_V2_1.00u
SW27: G; SW_Hotswap_Kailh_Choc_V2_1.00u
SW28: Shift; SW_Hotswap_Kailh_Choc_V2_2.25u
SW29: Z; SW_Hotswap_Kailh_Choc_V2_1.00u
SW30: X; SW_Hotswap_Kailh_Choc_V2_1.00u
SW31: C; SW_Hotswap_Kailh_Choc_V2_1.00u
SW32: V; SW_Hotswap_Kailh_Choc_V2_1.00u
SW33: B; SW_Hotswap_Kailh_Choc_V2_1.00u
SW34: Fn; SW_Hotswap_Kailh_Choc_V2_1.25u
SW35: Alt; SW_Hotswap_Kailh_Choc_V2_1.25u
SW36: OS; SW_Hotswap_Kailh_Choc_V2_1.25u
SW37: LANG1; SW_Hotswap_Kailh_Choc_V2_1.25u
SW38: Space; SW_Hotswap_Kailh_Choc_V2_2.00u
U1: ATmega32U4-M; QFN-44-1EP_7x7mm_P0.5mm_EP5.2x5.2mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, D1.1 (K), D42.3 (VDD), D43.3 (VDD), D44.3 (VDD), D45.3 (VDD), D46.3 (VDD), D47.3 (VDD), D48.3 (VDD), D49.3 (VDD), D50.3 (VDD), D51.3 (VDD), D52.3 (VDD), D53.3 (VDD), D54.3 (VDD), D55.3 (VDD), D56.3 (VDD), D57.3 (VDD), D58.3 (VDD), D59.3 (VDD), D60.3 (VDD), D61.3 (VDD), D62.3 (VDD), D63.3 (VDD), D64.3 (VDD), D65.3 (VDD), D66.3 (VDD), D67.3 (VDD), D68.3 (VDD), D69.3 (VDD), D70.3 (VDD), D71.3 (VDD), D72.3 (VDD), D73.3 (VDD), D74.3 (VDD), D75.3 (VDD), D76.3 (VDD), D77.3 (VDD), D78.3 (VDD), F1.2, J2.T, R6.2, R7.2, R8.2, R9.2, U1.1 (PE6), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC); also elsewhere on the board
Col0: SW1.2, SW8.2, U1.25 (PD4)
Col1: SW2.2, SW9.2, SW15.2, SW22.2, SW28.2, SW34.2, U1.26 (PD6)
Col2: SW3.2, SW10.2, SW16.2, SW23.2, SW29.2, SW35.2, U1.27 (PD7)
Col3: SW4.2, SW11.2, SW17.2, SW24.2, SW30.2, SW36.2, U1.28 (PB4)
Col4: SW5.2, SW12.2, SW18.2, SW25.2, SW31.2, SW37.2, U1.29 (PB5)
Col5: SW6.2, SW13.2, SW19.2, SW26.2, SW32.2, SW38.2, U1.30 (PB6)
Col6: SW7.2, SW14.2, SW20.2, SW27.2, SW33.2, U1.31 (PC6)
Col7: U1.10 (PB2)
Col8: U1.11 (PB3)
D+: R5.2, U1.4 (D+)
D-: R4.2, U1.3 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, D42.1 (VSS), D43.1 (VSS), D44.1 (VSS), D45.1 (VSS), D46.1 (VSS), D47.1 (VSS), D48.1 (VSS), D49.1 (VSS), D50.1 (VSS), D51.1 (VSS), D52.1 (VSS), D53.1 (VSS), D54.1 (VSS), D55.1 (VSS), D56.1 (VSS), D57.1 (VSS), D58.1 (VSS), D59.1 (VSS), D60.1 (VSS), D61.1 (VSS), D62.1 (VSS), D63.1 (VSS), D64.1 (VSS), D65.1 (VSS), D66.1 (VSS), D67.1 (VSS), D68.1 (VSS), D69.1 (VSS), D70.1 (VSS), D71.1 (VSS), D72.1 (VSS), D73.1 (VSS), D74.1 (VSS), D75.1 (VSS), D76.1 (VSS), D77.1 (VSS), D78.1 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.R2, R1.2, R2.2, R3.1, SW21.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.33 (~HWB/PE2), U1.35 (GND), U1.43 (GND), U1.45 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), SW1.1
unnamed: D3.2 (A), SW2.1
unnamed: D4.2 (A), SW3.1
unnamed: D5.2 (A), SW4.1
unnamed: D6.2 (A), SW5.1
unnamed: D7.2 (A), SW6.1
unnamed: D8.2 (A), SW7.1
unnamed: D9.2 (A), SW8.1
unnamed: D10.2 (A), SW9.1
unnamed: D11.2 (A), SW10.1
unnamed: D12.2 (A), SW11.1
unnamed: D13.2 (A), SW12.1
unnamed: D14.2 (A), SW13.1
unnamed: D15.2 (A), SW14.1
unnamed: D16.2 (A), R7.1
unnamed: D16.1 (K), U1.8 (PB0)
unnamed: D17.2 (A), SW15.1
unnamed: D18.2 (A), SW16.1
unnamed: D19.2 (A), SW17.1
unnamed: D20.2 (A), SW18.1
unnamed: D21.2 (A), SW19.1
unnamed: D22.2 (A), SW20.1
unnamed: D23.2 (A), R8.1
unnamed: D23.1 (K), U1.32 (PC7)
unnamed: D24.2 (A), SW22.1
unnamed: D25.2 (A), SW23.1
unnamed: D26.2 (A), SW24.1
unnamed: D27.2 (A), SW25.1
unnamed: D28.2 (A), SW26.1
unnamed: D29.2 (A), SW27.1
unnamed: D30.2 (A), R9.1
unnamed: D30.1 (K), U1.22 (PD5)
unnamed: D31.2 (A), SW28.1
unnamed: D32.2 (A), SW29.1
unnamed: D33.2 (A), SW30.1
unnamed: D34.2 (A), SW31.1
unnamed: D35.2 (A), SW32.1
unnamed: D36.2 (A), SW33.1
unnamed: D37.2 (A), SW34.1
unnamed: D38.2 (A), SW35.1
unnamed: D39.2 (A), SW36.1
unnamed: D40.2 (A), SW37.1
unnamed: D41.2 (A), SW38.1
unnamed: D42.4 (DOUT), D43.2 (DIN)
unnamed: D43.4 (DOUT), D44.2 (DIN)
unnamed: D44.4 (DOUT), D45.2 (DIN)
unnamed: D45.4 (DOUT), D46.2 (DIN)
unnamed: D46.4 (DOUT), D47.2 (DIN)
unnamed: D47.4 (DOUT), D48.2 (DIN)
unnamed: D48.4 (DOUT), D49.2 (DIN)
unnamed: D49.4 (DOUT), D50.2 (DIN)
unnamed: D50.4 (DOUT), D51.2 (DIN)
unnamed: D51.4 (DOUT), D52.2 (DIN)
unnamed: D52.4 (DOUT), D53.2 (DIN)
unnamed: D53.4 (DOUT), D54.2 (DIN)
unnamed: D54.4 (DOUT), D55.2 (DIN)
unnamed: D55.4 (DOUT), D56.2 (DIN)
unnamed: D56.4 (DOUT), D57.2 (DIN)
unnamed: D57.4 (DOUT), D58.2 (DIN)
unnamed: D58.4 (DOUT), D59.2 (DIN)
unnamed: D59.4 (DOUT), D60.2 (DIN)
unnamed: D60.4 (DOUT), D61.2 (DIN)
unnamed: D61.4 (DOUT), D62.2 (DIN)
unnamed: D62.4 (DOUT), D63.2 (DIN)
unnamed: D63.4 (DOUT), D64.2 (DIN)
unnamed: D64.4 (DOUT), D65.2 (DIN)
unnamed: D65.4 (DOUT), D66.2 (DIN)
unnamed: D66.4 (DOUT), D67.2 (DIN)
unnamed: D67.4 (DOUT), D68.2 (DIN)
unnamed: D68.4 (DOUT), D69.2 (DIN)
unnamed: D69.4 (DOUT), D70.2 (DIN)
unnamed: D70.4 (DOUT), D71.2 (DIN)
unnamed: D71.4 (DOUT), D72.2 (DIN)
unnamed: D72.4 (DOUT), D73.2 (DIN)
unnamed: D73.4 (DOUT), D74.2 (DIN)
unnamed: D74.4 (DOUT), D75.2 (DIN)
unnamed: D75.4 (DOUT), D76.2 (DIN)
unnamed: D76.4 (DOUT), D77.2 (DIN)
unnamed: D77.4 (DOUT), D78.2 (DIN)
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J1.A6 (D+), J1.B6 (D+), R5.1
unnamed: J1.A7 (D-), J1.B7 (D-), R4.1
unnamed: C7.1, U1.42 (AREF)
unnamed: C8.2, U1.6 (UCAP)
unnamed: C5.1, U1.17 (XTAL1), Y1.3
unnamed: C6.1, U1.16 (XTAL2), Y1.1
unnamed: R6.1, SW21.2, U1.13 (~RESET)
RGB Light: D42.2 (DIN), U1.12 (PB7)
Row0: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), U1.36 (PF7)
Row1: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), U1.37 (PF6)
Row2: D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), U1.38 (PF5)
Row3: D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), U1.39 (PF4)
Row4: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.40 (PF1)
Row5: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), U1.41 (PF0)
SCL: J2.R1, U1.18 (PD0)
SDA: J2.S, U1.19 (PD1)
VBUS: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.2 (UVCC), U1.7 (VBUS)

Notes on the sheet:
分割判定フラグ （R側ではGNDに接続）
RX LED
CapsLock
TX LED

Board: 2 copper layers, 140.5 x 119.1 mm, 139 parts (102 on the bottom side), 110 nets.

Other parts of the board:
D9#2: 1N4148W; D_SOD-323

Their connections:
+5V: D9#2.1 (K); also elsewhere on the board
GND: D9#2.2 (A); also elsewhere on the board

## KiCad design KiCad_Kailh_R_pcb/KiCad_Kailh_R_pcb.kicad_pcb

Parts:
C1, C2: C; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43: 1N4148W; D_SOD-323
D44: LED; LED_0805_2012Metric
J1: AudioJack3_SwitchTR; Jack_3.5mm_CUI_SJ1-3515N_Horizontal
J2: Reset; PinHeader_1x01_P1.00mm_Vertical
R1: 10k; R_0805_2012Metric
SW1: 7; SW_Hotswap_Kailh_Choc_V2_1.00u
SW2: 8; SW_Hotswap_Kailh_Choc_V2_1.00u
SW3: 9; SW_Hotswap_Kailh_Choc_V2_1.00u
SW4: 0; SW_Hotswap_Kailh_Choc_V2_1.00u
SW5: -; SW_Hotswap_Kailh_Choc_V2_1.00u
SW6: =; SW_Hotswap_Kailh_Choc_V2_1.00u
SW7: `; SW_Hotswap_Kailh_Choc_V2_1.00u
SW8: Y; SW_Hotswap_Kailh_Choc_V2_1.00u
SW9: U; SW_Hotswap_Kailh_Choc_V2_1.00u
SW10: I; SW_Hotswap_Kailh_Choc_V2_1.00u
SW11: O; SW_Hotswap_Kailh_Choc_V2_1.00u
SW12: P; SW_Hotswap_Kailh_Choc_V2_1.00u
SW13: [; SW_Hotswap_Kailh_Choc_V2_1.00u
SW14: ]; SW_Hotswap_Kailh_Choc_V2_1.00u
SW15: H; SW_Hotswap_Kailh_Choc_V2_1.00u
SW16: J; SW_Hotswap_Kailh_Choc_V2_1.00u
SW17: K; SW_Hotswap_Kailh_Choc_V2_1.00u
SW18: L; SW_Hotswap_Kailh_Choc_V2_1.00u
SW19: ;; SW_Hotswap_Kailh_Choc_V2_1.00u
SW20: '; SW_Hotswap_Kailh_Choc_V2_1.00u
SW21: \; SW_Hotswap_Kailh_Choc_V2_1.00u
SW22: B; SW_Hotswap_Kailh_Choc_V2_1.00u
SW23: N; SW_Hotswap_Kailh_Choc_V2_1.00u
SW24: M; SW_Hotswap_Kailh_Choc_V2_1.00u
SW25: ,; SW_Hotswap_Kailh_Choc_V2_1.00u
SW26: .; SW_Hotswap_Kailh_Choc_V2_1.00u
SW27: /; SW_Hotswap_Kailh_Choc_V2_1.00u
SW28: Shift; SW_Hotswap_Kailh_Choc_V2_1.75u
SW29: Space; SW_Hotswap_Kailh_Choc_V2_2.00u
SW30: Conv; SW_Hotswap_Kailh_Choc_V2_1.25u
SW31: Win; SW_Hotswap_Kailh_Choc_V2_1.25u
SW32: Fn; SW_Hotswap_Kailh_Choc_V2_1.25u
SW33: ←; SW_Hotswap_Kailh_Choc_V2_1.00u
SW34: ↑; SW_Hotswap_Kailh_Choc_V2_1.00u
SW35: ↓; SW_Hotswap_Kailh_Choc_V2_1.00u
SW36: BS; SW_Hotswap_Kailh_Choc_V2_1.00u
SW37: Enter; SW_Hotswap_Kailh_Choc_V2_ISOEnter
SW38: Home; SW_Hotswap_Kailh_Choc_V2_1.00u
SW39: End; SW_Hotswap_Kailh_Choc_V2_1.00u
SW40: →; SW_Hotswap_Kailh_Choc_V2_1.00u
SW41: Free; SW_Hotswap_Kailh_Choc_V2_1.00u
SW42: PrtSc; SW_Hotswap_Kailh_Choc_V2_1.00u
U1: Sparkfun_Pro_Micro

Connections:
+5V: C1.1, C2.1, D43.1 (K), J1.R, U1.21 (VCC)
Col0: SW1.1, SW8.1, SW15.1, SW22.1, SW29.1, SW36.1, U1.20 (D21/A3)
Col1: SW2.1, SW9.1, SW16.1, SW23.1, SW30.1, SW37.1, U1.19 (D20/A2)
Col2: SW3.1, SW10.1, SW17.1, SW24.1, SW31.1, SW38.1, U1.18 (D19/A1)
Col3: SW4.1, SW11.1, SW18.1, SW25.1, SW32.1, SW39.1, U1.17 (D18/A0)
Col4: SW5.1, SW12.1, SW19.1, SW26.1, SW33.1, SW40.1, U1.16 (D15)
Col5: SW6.1, SW13.1, SW20.1, SW27.1, SW35.1, SW42.1, U1.15 (D14)
Col6: SW7.1, SW14.1, SW21.1, SW28.1, SW34.1, SW41.1, U1.14 (D16)
GND: C1.2, C2.2, D43.2 (A), J1.S, R1.1, U1.3 (GND), U1.4 (GND), U1.13 (~D10/A10), U1.23 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D44.2 (A), U1.2 (D0/RX)
unnamed: D44.1 (K), R1.2
unnamed: J2.1, U1.22 (RST)
Row5: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), U1.7 (D4/A6)
Row6: D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U1.8 (~D5)
Row7: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), U1.9 (~D6/A7)
Row8: D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), U1.10 (D7)
Row9: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), U1.11 (D8/A8)
Row10: D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U1.12 (~D9/A9)
SCL: J1.T, U1.6 (~D3)
SDA: U1.5 (D2)

Notes on the sheet:
分割判定フラグ （R側ではGNDに接続）

Board: 2 copper layers, 92 parts (47 on the bottom side), 61 nets, no tracks yet.

## Commit log (part)

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2026-04-19 build: Add `.gitignore`
2026-04-19 build: Add the Right KiCad project
2026-04-19 build: Add the Left KiCad project
2026-04-19 build: Add the Left firmware
2026-04-19 docs: Move and edit README
2026-04-22 feat: ファームウェアのためのmatrixを記述
2026-04-22 docs: layoutの情報を追加
2026-04-23 build: Update `.gitignore`
2026-04-23 feat: Leftの回路データが完成
2026-04-23 docs: layoutの情報を変更
2026-04-23 docs: layoutの画像を再追加
2026-04-23 docs: Edit README
2026-04-25 feat: Leftの各データが完成
2026-04-25 feat: Leftのファームウェアが完成
2026-04-25 docs: ドキュメント群を整理
2026-04-25 feat: LeftをVialに対応
2026-04-25 docs: READMEを移動して編集
2026-04-25 refactor: 基板データとそれ以外で分類
2026-04-25 refactor: 作り直し
2026-04-25 feat: Leftのガワが再び完成
2026-04-25 feat: Rightの配置が完了
2026-04-26 feat: 左右のファームウェアを統合して完成
2026-04-26 feat: Resetピンを追加
2026-04-26 feat: MIDIモードを追加
2026-04-26 feat: Rightのガワを用意
2026-04-26 feat: ガワがすべて完成
2026-05-30 docs: Add docs
2026-05-30 feat: Add firmware
2026-05-30 feat: Add KiCad files for PCB
2026-05-30 feat: Add KiCad files for case
2026-05-30 docs: Update README
2026-06-04 feat: `LGUI`と`LALT`を入れ替え
2026-06-14 fix: スタビライザー周りの干渉を修正
2026-06-14 feat: 起動時のLEDアニメーションを実装
2026-06-14 feat: スリープ時のLED消灯を実装
2026-06-14 refactor: ヘッダーを編集すれば済むよう分割
2026-06-17 refactor: 記述順を入れ替え
2026-06-17 feat: マウスキーを追加
2026-06-18 build: atmega32u4用に設定を更新
2026-06-18 perf: TAP機能を強引に削除
2026-06-18 feat: キーマップの追加と編集
2026-06-18 feat: MIDI機能を追加
2026-06-18 feat: LEDアニメーションの切り替わりを実装
2026-06-23 docs: Delete repo's QR
